<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>minsize</key><value>10</value></param>
<param><key>maxsize</key><value>50</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>ncols</key><value>100</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>chunky_replicate</key>
<param><key>id</key><value>chunky_replicate_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>k</key><value>3</value></param>
</block>
<block>
<key>chunky_avg_n_ff</key>
<param><key>id</key><value>chunky_avg_n_ff_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
</block>
<block>
<key>chunky_replicate</key>
<param><key>id</key><value>chunky_replicate_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>k</key><value>3</value></param>
</block>
<block>
<key>chunky_replicate</key>
<param><key>id</key><value>chunky_replicate_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>k</key><value>5</value></param>
</block>
<block>
<key>chunky_avg_n_ff</key>
<param><key>id</key><value>chunky_avg_n_ff_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>k</key><value>3</value></param>
</block>
<block>
<key>chunky_replicate</key>
<param><key>id</key><value>chunky_replicate_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>k</key><value>2</value></param>
</block>
<block>
<key>chunky_avg_n_ff</key>
<param><key>id</key><value>chunky_avg_n_ff_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>k</key><value>2</value></param>
</block>
<block>
<key>chunky_avg_n_ff</key>
<param><key>id</key><value>chunky_avg_n_ff_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>k</key><value>4</value></param>
</block>
<block>
<key>chunky_source</key>
<param><key>id</key><value>chunky_source_0</value></param>
<param><key>min</key><value>100</value></param>
<param><key>max</key><value>200</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>chunky_sink</key>
<param><key>id</key><value>chunky_sink_0</value></param>
<param><key>maxlen</key><value>200</value></param>
<param><key>exitafter</key><value>int(1e6)</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>test_tsb_b0</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>chunky_source_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chunky_source_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>chunky_avg_n_ff_0_0_0_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chunky_avg_n_ff_0_0_0_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chunky_avg_n_ff_0_0_0_0</source_block_id><sink_block_id>chunky_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chunky_source_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chunky_source_0</source_block_id><sink_block_id>chunky_replicate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chunky_avg_n_ff_0_0_0</source_block_id><sink_block_id>chunky_replicate_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chunky_avg_n_ff_0_0</source_block_id><sink_block_id>chunky_replicate_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chunky_replicate_0_0_0</source_block_id><sink_block_id>chunky_avg_n_ff_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chunky_replicate_0_0</source_block_id><sink_block_id>chunky_avg_n_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chunky_avg_n_ff_0</source_block_id><sink_block_id>chunky_replicate_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chunky_replicate_0</source_block_id><sink_block_id>chunky_avg_n_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chunky_replicate_0_0_0_0</source_block_id><sink_block_id>chunky_avg_n_ff_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>chunky_source_0</source_block_id><sink_block_id>chunky_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
