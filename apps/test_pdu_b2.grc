<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_pdu_b2</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>chunky_source</key>
<param><key>id</key><value>chunky_source_0</value></param>
<param><key>min</key><value>100</value></param>
<param><key>max</key><value>200</value></param>
</block>
<block>
<key>chunky_avg_n_fpdu</key>
<param><key>id</key><value>chunky_avg_n_fpdu_0</value></param>
<param><key>k</key><value>3</value></param>
</block>
<block>
<key>chunky_avg_n_fpdu</key>
<param><key>id</key><value>chunky_avg_n_fpdu_0_0</value></param>
<param><key>k</key><value>3</value></param>
</block>
<block>
<key>chunky_sink</key>
<param><key>id</key><value>chunky_sink_0</value></param>
<param><key>maxlen</key><value>200</value></param>
</block>
<connection><source_block_id>chunky_source_0</source_block_id><sink_block_id>chunky_avg_n_fpdu_0</sink_block_id><source_key>pdus</source_key><sink_key>fpdus</sink_key></connection>
<connection><source_block_id>chunky_avg_n_fpdu_0</source_block_id><sink_block_id>chunky_avg_n_fpdu_0_0</sink_block_id><source_key>fpdus</source_key><sink_key>fpdus</sink_key></connection>
<connection><source_block_id>chunky_avg_n_fpdu_0_0</source_block_id><sink_block_id>chunky_sink_0</sink_block_id><source_key>fpdus</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
